# Keil uVision project Template.uvproj, settings and files
target Debug (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\core;..\USER;..\USER\delay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c gpio.c uart.c
    ../USER/delay/: delay.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
    ../STM32F10x_FWLib/core/: startup_stm32f10x_hd.s
target Release (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: as above
  output: Template +hex
  c flags: Optim=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\core;..\USER;..\USER\delay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
